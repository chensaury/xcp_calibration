AUTOSAR XML (schema 4-2-1)
package /VehicleProject
  system System
package /Cluster
  can cluster CAN00: protocol-name=CAN  # CA_NoramlCAN
    can physical channel CHNL: comm-connectors=CN_CAN00
      frame ACP_327_oCAN00: id 0x327, to ITMS, frame-length=8, can-addressing-mode=STANDARD
        pdu ACP_327_oCAN00: length=8, minimum-delay=0.001, transmission-mode-false-timing=cyclic-timing={time-offset=0, time-period=0.1}, transmission-mode-true-timing=cyclic-timing={time-offset=0, time-period=0.1}, unused-bit-pattern=0
          signal Ecomp_InvSoftwareVer_oACP_327_oCAN00: start 7, 16 bit, big-endian, init-value=0, base-type=uint16, compu-method=CM_Ecomp_InvSoftwareVer, data-constr=DC_Ecomp_InvSoftwareVer, transfer-property=PENDING, to ITMS
          signal Ecomp_CompIpt_V_oACP_327_oCAN00: start 23, 16 bit, big-endian, init-value=0, base-type=uint16, compu-method=CM_Ecomp_CompIpt_V, unit=U_V, transfer-property=PENDING, to ITMS  # 0x0~0xFFFE:voltage 0xFFFF:error
          signal Ecomp_Complpt_A_oACP_327_oCAN00: start 39, 16 bit, big-endian, init-value=0, base-type=uint16, compu-method=CM_Ecomp_Complpt_A, unit=U_A, transfer-property=PENDING, to ITMS  # 0x0~0xFFFE:current 0xFFFF:error
      frame ACP_32E_oCAN00: id 0x32E, to ITMS, frame-length=8, can-addressing-mode=STANDARD
        pdu ACP_32E_oCAN00: length=8, minimum-delay=0.001, transmission-mode-false-timing=cyclic-timing={time-offset=0, time-period=0.1}, transmission-mode-true-timing=cyclic-timing={time-offset=0, time-period=0.1}, unused-bit-pattern=0
          signal Comp_speed_of_compressor_oACP_32E_oCAN00: start 7, 16 bit, big-endian, init-value=0, base-type=uint16, compu-method=CM_Comp_speed_of_compressor, data-constr=DC_Comp_speed_of_compressor, unit=U_rpm, transfer-property=PENDING, to ITMS  # 压缩机目标转速
          signal Comp_work_status_oACP_32E_oCAN00: start 31, 8 bit, big-endian, init-value=0, base-type=uint8, compu-method=CM_Comp_work_status, transfer-property=PENDING, to ITMS
          signal Comp_error_code1_oACP_32E_oCAN00: start 39, 8 bit, big-endian, init-value=0, base-type=uint8, compu-method=CM_Comp_error_code1, data-constr=DC_Comp_error_code1, transfer-property=PENDING, to ITMS  # 压缩机故障码1
      frame B_RLS_oCAN00: id 0x3E6, to ITMS, frame-length=8, can-addressing-mode=STANDARD
        pdu B_RLS_oCAN00: length=8, minimum-delay=0.001, transmission-mode-false-timing=cyclic-timing={time-offset=0, time-period=0.1}, transmission-mode-true-timing=cyclic-timing={time-offset=0, time-period=0.1}, unused-bit-pattern=0
          signal B_RLS_SolarLeft_oB_RLS_oCAN00: start 7, 8 bit, big-endian, init-value=0, base-type=uint8, compu-method=CM_B_RLS_SolarLeft, transfer-property=PENDING, to ITMS  # 左侧光照强度
          signal B_RLS_SolarRight_oB_RLS_oCAN00: start 15, 8 bit, big-endian, init-value=0, base-type=uint8, compu-method=CM_B_RLS_SolarRight, transfer-property=PENDING, to ITMS  # 右侧光照强度
          signal B_RLS_relativeHumidity_oB_RLS_oCAN00: start 23, 8 bit, big-endian, init-value=1, base-type=uint8, compu-method=CM_B_RLS_relativeHumidity, transfer-property=PENDING, to ITMS  # 相对湿度
          signal B_RLS_WindshieldTemp_oB_RLS_oCAN00: start 31, 8 bit, big-endian, init-value=80, base-type=uint8, compu-method=CM_B_RLS_WindshieldTemp, transfer-property=PENDING, to ITMS  # 前挡风玻璃温度
          signal B_RLS_DewPoint_oB_RLS_oCAN00: start 33, 10 bit, big-endian, init-value=396, base-type=uint16, compu-method=CM_B_RLS_DewPoint, transfer-property=PENDING, to ITMS  # 露点温度
          signal B_RLS_Offline_Calibration_Result_oB_RLS_oCAN00: start 49, 2 bit, big-endian, init-value=0, base-type=uint8, compu-method=CM_B_RLS_Offline_Calibration_Result, transfer-property=PENDING, to ITMS  # 线下配置结果
      frame ITMS_350_oCAN00: id 0x350, from ITMS, frame-length=8, can-addressing-mode=STANDARD
        pdu ITMS_350_oCAN00: length=8, minimum-delay=0.001, transmission-mode-false-timing=cyclic-timing={time-offset=0, time-period=0.1}, transmission-mode-true-timing=cyclic-timing={time-offset=0, time-period=0.1}, unused-bit-pattern=0
          signal AC_max_perm_compressor_power_oITMS_350_oCAN00: start 7, 8 bit, big-endian, init-value=0, base-type=uint8, compu-method=CM_AC_max_perm_compressor_power, unit=U_kw, transfer-property=PENDING  # 最大允许压缩机消耗功率
          signal AllowOperation_Flag_oITMS_350_oCAN00: start 24, 1 bit, big-endian, init-value=0, base-type=boolean, compu-method=CM_AllowOperation_Flag, transfer-property=PENDING  # 压缩机开关机命令
          signal TgtSpd_rpm_oITMS_350_oCAN00: start 55, 16 bit, big-endian, init-value=0, base-type=uint16, compu-method=CM_TgtSpd_rpm, data-constr=DC_TgtSpd_rpm, unit=U_rpm, transfer-property=PENDING  # 0x00~0xFFFE:0~65535rpm 0xFFFF:error
      frame XCP_R_oCAN00: id 0x6FE, from ITMS, frame-length=8, can-addressing-mode=STANDARD
        xcp pdu XCP_R_oCAN00: length=8
      frame XCP_S_oCAN00: id 0x6FF, to ITMS, frame-length=8, can-addressing-mode=STANDARD
        xcp pdu XCP_S_oCAN00: length=8
package /ECU
  ecu instance ITMS: associated-com-i-pdu-group=[ITMS_oCAN00_Rx, ITMS_oCAN00_Tx]
    can communication controller CT_CAN00
    can communication connector CN_CAN00: comm-controller=CT_CAN00
package /IPDUGroup
  i signal i pdu group ITMS_oCAN00_Rx: communication-direction=IN, i-signal-i-pdus=[ACP_327_oCAN00, ACP_32E_oCAN00, B_RLS_oCAN00]
  i signal i pdu group ITMS_oCAN00_Tx: communication-direction=OUT, i-signal-i-pdus=ITMS_350_oCAN00
